PACKAGECONFIG:append:meson-gx = "lima panfrost"
